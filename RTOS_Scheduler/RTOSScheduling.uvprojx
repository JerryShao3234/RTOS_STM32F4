# Keil uVision project RTOSScheduling.uvprojx, settings and files
target stm32f411 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSScheduling
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group osKernel
    ./: osKernel.c osKernel.s osKernel.h
  group user
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
